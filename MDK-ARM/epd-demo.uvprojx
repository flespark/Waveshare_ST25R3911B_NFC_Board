# Keil uVision project epd-demo.uvprojx, settings and files
target epd-demo (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: epd-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;                         ../Drivers/STM32F1xx_HAL_Driver/Inc;                         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                         ../Middlewares/Third_Party/FatFs/src;                         ../Drivers/CMSIS/Include;                         ..\User\BSP;                         ..\User\Config;                         ..\User\SDcard;                         ..\User\Fonts;                         ..\User\SSD1306;                         ..\User\Browser;                         ..\User\Key;                         ..\User\BSP\ST25R3911;                         ..\Middlewares\ST\rfal\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: logger.c demo.c main.c gpio.c user_diskio.c fatfs.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Config
    ../User/Config/: DEV_Config.c
  group BSP
    ../User/BSP/: GUI_Paint.c SPI_RAM.c
  group SDcard
    ../User/SDcard/: SD_Card_APP.c SD_Card_Drive.c SD_Card_Interface.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group OLED
    ../User/SSD1306/: SSD1306.c
    ../User/Fonts/: Fonts.c
  group Browser
    ../User/Browser/: Browser.c
  group Key
    ../User/Key/: Key.c
  group ST25R3911
    ../User/BSP/ST25R3911/: st25r3911.c st25r3911_com.c st25r3911_interrupt.c timer.c
  group RFAL
    ../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_rfst25r3911.c rfal_st25tb.c rfal_t1t.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.0
